<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\4WD Rover.ewp</path>
  </project>
  <batchBuild />
</workspace>
